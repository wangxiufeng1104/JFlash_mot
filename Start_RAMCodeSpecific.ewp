# IAR project Start_RAMCodeSpecific.ewp, settings and files
configuration Release_RAMCode_CortexM (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: F:\JFlash-RamCode\JFlash-RamCode\Inc; F:\JFlash-RamCode\JFlash-RamCode\Src; F:\JFlash-RamCode\JFlash-RamCode\Src\flash
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: INC\
  OBJCOPY.OOCOutputFile: LN821x_Flash_2MB.mot
  ILINK.IlinkOutputFile: RAMCodeSpecific_Release.out
  ILINK.IlinkIcfFile: Setup\RAMCode_Specific_Release.icf
  ILINK.IlinkExtraOptions: --pi_veneers; --cpu=Cortex-M0
  ILINK.IlinkProgramEntryLabel: _RAMCode_Entry
  group Inc
    Inc/: RAMCodeV2.h
  group Lib
    Lib/: Specific_CortexM_ASM_LE.o
  group Setup
    Setup/: RAMCode_Specific_Release.icf
  group Src
    Src/: RAMCode_Specific_Template.c
  group Src/driver
    Src/flash/: flash.c
