# IAR project Backup of Start_RAMCodeSpecific.ewp, settings and files
configuration Release_RAMCode_CortexM (ARM)
  General.OGChipSelectEditMenu: AT91SAM9261EK Atmel AT91SAM9261EK
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.IExtraOptions: --silent
  ICCARM.CCIncludePath2: Inc\; ..\..\Trunk\plf\bx2400\src\driver\ssi; ..\..\Trunk\plf\bx2400\src\driver\ssi\qspi; ..\..\Trunk\plf\bx2400\src\driver\flash; ..\..\Trunk\plf\bx2400\src\driver\dmac; ..\..\Trunk\plf\bx2400\src\driver\reg; ..\..\Trunk\plf\bx2400\src\bx_debug; ..\..\Trunk\plf\bx2400\src\arch; ..\..\Trunk\plf\bx2400\src\cmsis_inc; ..\..\Trunk\plf\bx2400\src\driver\sysctrl; ..\..\Trunk\plf\bx2400\src\bx_debug\log; ..\..\Trunk\modules\common\api; ..\..\Trunk\plf\bx2400\src\arch\compiler\iar
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: INC\
  OBJCOPY.OOCOutputFile: RAMCodeSpecific_Release.mot
  ILINK.IlinkOutputFile: RAMCodeSpecific_Release.out
  ILINK.IlinkIcfFile: Setup\RAMCode_Specific_Release.icf
  ILINK.IlinkExtraOptions: --pi_veneers; --cpu=Cortex-M0
  ILINK.IlinkProgramEntryLabel: _RAMCode_Entry
  group Inc
    Inc/: RAMCodeV2.h
  group Lib
    Lib/: Specific_CortexM_ASM_LE.o
  group Setup
    Setup/: RAMCode_Specific_Release.icf
  group Src
    Src/: RAMCode_Specific_Template.c
  group Src/driver
    ../../Trunk/plf/bx2400/src/driver/dmac/: dma_for_qspi.c dma_for_qspi_rom.c
    ../../Trunk/plf/bx2400/src/driver/flash/: flash.c flash_rom.c
    ../../Trunk/plf/bx2400/src/driver/ssi/qspi/: qspi.c qspi_rom.c
